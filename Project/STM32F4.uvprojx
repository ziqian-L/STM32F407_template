# Keil uVision project STM32F4.uvprojx, settings and files
target TI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CODE_ARM;..\FWLIB_ST\inc;..\SYSTEM;..\USER\Drive;..\USER\Hardware;..\USER\Hardware\MPU6050;..\USER\Hardware\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLIB_ST
    ../FWLIB_ST/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DRIVE
    ../USER/: main.c
    ../USER/Drive/: sys.c delay.c usart.c motor.c encoder.c control.c timer.c pid.c cJSON.c
  group HARDWARE
    ../USER/Hardware/: led.c key.c buzz.c oled.c servos.c ultrasound.c graysensor.c sw_i2c.c matrixkey.c mlx90614.c
    ../USER/Hardware/MPU6050/: mpu6050.c mpuiic.c mpuexti.c
    ../USER/Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
